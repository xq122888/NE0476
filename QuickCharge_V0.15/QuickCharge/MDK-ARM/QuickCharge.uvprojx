# Keil uVision project QuickCharge.uvprojx, settings and files
target QuickCharge (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: QuickCharge +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf.exe --text -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_FULL_LL_DRIVER,USE_HAL_DRIVER
  c include: ../Core/Inc;                                                               ../Drivers/STM32F3xx_HAL_Driver/Inc;                                                               ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                                               ../Drivers/CMSIS/Include; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: usbpd_sm.c usbpd_phy_4b5b.c usbpd_phy_crc32.c usbpd_phy_decode.c usbpd_phy_encode.c usbpd_msgrcv.c usbpd_msgtrans.c usbpd_prl.c usbpd_dpm_user.c usbqc.c timer.c measure.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_adc.c stm32f3xx_ll_dma.c stm32f3xx_ll_rcc.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_tim.c
software components: CMSIS:CORE 4.3.0
